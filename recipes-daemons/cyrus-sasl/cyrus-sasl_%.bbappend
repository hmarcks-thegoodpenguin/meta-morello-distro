# Required to make zabbix build with necassary users in place
GROUPADD_PARAM:${PN}-bin = " -r mail "
